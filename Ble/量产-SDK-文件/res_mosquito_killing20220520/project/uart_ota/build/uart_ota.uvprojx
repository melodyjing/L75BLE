# Keil uVision project uart_ota.uvprojx, settings and files
target uart_ota (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: uart_ota
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --thumb --preinclude  app_config.h --gnu --diag_suppress=1,120,47,94,940,167,188,231,513,177,144,111,186,223,550,1294,1295,6314,66,61,68,1254,3087,3128
  c include: ..\..\..\modules\rwip\api;..\..\..\plf\arch;..\..\..\modules\rwip\api;..\..\..\modules\ke\api;..\..\..\modules\common\api;..\..\..\modules\dbg\api;..\..\..\modules\h4tl\api;..\..\..\modules\aes\api;..\..\..\modules\ecc_p256\api;..\..\..\modules\nvds\api;..\..\..\modules\rf\api;..\..\..\ip\ble\hl\api;..\..\..\ip\ble\hl\inc;..\..\..\ip\hci\api;..\..\..\ip\ble\hl\api;..\..\..\modules\rwip\api;..\..\..\ip\ble\ll\api;..\..\..\ip\sch\api;..\..\..\app\api;..\..\..\ip\ble\ll\src\co;..\..\..\ip\ble\ll\src;..\..\..\ip\em\api;..\..\..\plf\refip\src\build\ble-full\reg\fw;..\..\..\plf\refip\src\driver\reg;..\..\..\plf\refip\src\driver\plf;..\..\..\ip\ble\profiles\blp;..\..\..\ip\ble\profiles\blp\blps\api;..\..\..\ip\ble\profiles\htp;..\..\..\ip\ble\profiles\htp\htpt\api;..\..\..\driver;..\..\..\driver\app_rdw_gpio;..\..\..\driver\app_rdw_dma;..\..\..\driver\app_system_trim;..\..\..\app\rdw_nRF24L01_v2;..\..\..\driver\app_background_task;..\..\..\app\rdw_csem;..\..\..\ip\ahi\api;..\..\..\driver\cobra_button;..\..\..\app\cobra_driver_test;..\..\..\driver\rdw_uart_driver;..\..\..\app\rdw_use_profile;..\..\..\ip\ble\profiles\hrp\hrps\api;..\..\..\ip\ble\profiles\hrp\hrps\src;..\..\..\app\ota_eflash;..\..\..\ip\ble\profiles\hrp;..\..\..\ip\ble\profiles\blp\blps;..\..\..\ip\ble\profiles\blp\blps\src;..\..\..\ip\ble\profiles\blp\blps\api;..\..\..\app\app_button;..\..\..\app\rdw_console;..\..\..\app\src;..\..\..\app\new_uart_profile;..\..\..\ip\ble\mesh\api;..\..\..\ip\ble\mesh\inc;..\..\..\ip\ble\mesh\inc_al;..\..\..\ip\ble\mesh\src\inc;..\..\..\ip\ble\mesh\src\prf\inc;..\..\..\ip\ble\mesh\src\common\inc;..\..\..\ip\ble\mesh\src\models\inc;..\..\..\ip\ble\mesh\src\models\src;..\..\..\ip\ble\mesh\al;..\..\..\ip\ble\mesh\src\prf;..\..\..\ip\ble\mesh\src\models\src\gen\genc;..\..\..\ip\ble\mesh\src\models\src\gen\gens;..\..\..\app\app_mesh;..\..\..\driver\cobra_multi_timer;..\..\..\app\app_realtek\device1_collector;..\..\..\app\app_realtek\device1_uart;..\..\..\app\app_realtek\device2_uart;..\..\..\app\app_realtek\host_uart;..\..\..\app\app_realtek;..\..\..\app\app_realtek\realtek_calculate;..\..\..\app\app_realtek\realtek_device;..\..\..\app\app_realtek\uart_cmd_handler;..\..\..\driver\cobra_mmu;..\..\..\driver\cobra_softtimer;..\..\..\app\app_ota_master;..\..\..\app\app_shell;..\..\..\driver\rdw_queue;..\..\..\driver\cobra_src;..\..\..\driver\cobra_pll;..\..\..\app\app_mesh\app_leishunke;..\..\..\app\app_wireless_hid;..\..\..\app\app_example_ledbutton\inc;..\..\..\app\app_wireless_receiver;..\..\..\app\app_wireless_send;..\..\..\driver\app_adc;..\..\..\driver\cobra_wm8978;..\..\..\driver\rdw_prf_utils;..\..\..\app\app_meter_at_module;..\..\..\app\app_meter_at_module\slave_com_profile;..\..\..\app\app_meter_at_module\master_com_profile;..\..\..\app\app_meter_at_module\app_host1;..\..\..\app\app_meter_at_module\app_host2;..\..\..\app\sfud;..\..\..\app\app_at_command;..\..\..\app\app_easylogger;..\..\..\app\app_umouse;..\..\..\app\app_easylogger\inc;..\..\..\app\app_wireless_mcu;..\..\..\app\sfud\inc;..\build
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\uart_ota.sct
  group main
    ../../../app/: main.c cobra4_ble_common.c cobra4_common.c cobra4_rdw_common.c
    ../../../plf/arch/: retargetio.c
  group app
    ../../../app/src/: app.c app_sec.c app_task.c
  group driver
    ../../../driver/app_adc/: rdw_adc.c
    ../../../driver/app_background_task/: app_bk_task.c
    ../../../driver/app_rdw_dma/: rdw_dma.c
    ../../../driver/app_rdw_gpio/: rdw_gpio.c
    ../../../driver/cobra_button/: cobra_button.c
    ../../../driver/cobra_mmu/: cobra_mmu.c
    ../../../driver/cobra_multi_timer/: cobra_multi_timer.c
    ../../../driver/cobra_pll/: cobra_pll.c
    ../../../driver/cobra_softtimer/: cobra4A_link.c cobra4A_linked_softtimer.c
    ../../../driver/cobra_src/: cobra_src.c
    ../../../driver/: cobra_aon_dcdc.c cobra_aon_pmu.c cobra_cache_ctrl.c cobra_ceva_baseband.c cobra_dualtimer.c cobra_dualtimer_aon.c cobra_ecc.c cobra_i2c.c cobra_i2s.c cobra_irda.c cobra_pcrm.c cobra_pdm.c cobra_pinmux.c cobra_rtc.c cobra_sha256.c cobra_soft_timer.c cobra_soft_uart.c cobra_spi_flash_ctrl.c cobra_system.c cobra_timer.c cobra_trng.c cobra_uart.c cobra_udma.c cobra_watchdog.c cobra4_aes.c cobra4_aon_top.c cobra4_aon_wk.c cobra4_gpadc.c cobra4_systick.c cobra4A_mpwm.c cobra4A_spwm.c cobra4C_eflash_ctrl.c cobra4_d_vad.c cobra_umcu.c cobra_m4_gpio.c
    ../../../driver/rdw_queue/: rdw_queue.c
  group app_ota
    ../../../app/app_ota_master/: app_ota_scan.c app_ota_scan_task.c ota_device.c ota_device_task.c ota_master.c ota_master_task.c ota_shell.c ota_shell_cmd.c
  group ip
    ../../../ip/ble/ll/src/co/: ble_util_buf.c rwble.c
  group lib
    ../../../lib/: cobra4.lib
  group app_shell
    ../../../app/app_shell/: app_rdw_shell.c shell.c shell_cmd_list.c shell_ext.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.1
