# Keil uVision project mosquito_killing.uvprojx, settings and files
target wechatble (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: cobra4
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o bin\cobra4.bin  Objects\cobra4.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: COBRA_OTA_ENABLE
  c misc: --thumb --preinclude  app_config.h --gnu --diag_suppress=1,120,47,94,940,167,188,231,513,177,144,111,186,223,550,1294,1295,6314,66,61,68,1254,3087,3128
  c include: ..\..\..\modules\rwip\api;..\..\..\plf\arch;..\..\..\modules\rwip\api;..\..\..\modules\ke\api;..\..\..\modules\common\api;..\..\..\modules\dbg\api;..\..\..\modules\h4tl\api;..\..\..\modules\aes\api;..\..\..\modules\ecc_p256\api;..\..\..\modules\nvds\api;..\..\..\modules\rf\api;..\..\..\ip\ble\hl\api;..\..\..\ip\ble\hl\inc;..\..\..\ip\hci\api;..\..\..\ip\ble\hl\api;..\..\..\modules\rwip\api;..\..\..\ip\ble\ll\api;..\..\..\ip\sch\api;..\..\..\app\api;..\..\..\ip\ble\ll\src\co;..\..\..\ip\ble\ll\src;..\..\..\ip\em\api;..\..\..\plf\refip\src\build\ble-full\reg\fw;..\..\..\plf\refip\src\driver\reg;..\..\..\plf\refip\src\driver\plf;..\..\..\ip\ble\profiles\blp;..\..\..\ip\ble\profiles\blp\blps\api;..\..\..\ip\ble\profiles\htp;..\..\..\ip\ble\profiles\htp\htpt\api;..\..\..\driver;..\..\..\driver\app_rdw_gpio;..\..\..\driver\app_rdw_dma;..\..\..\driver\app_system_trim;..\..\..\app\rdw_nRF24L01_v2;..\..\..\driver\app_background_task;..\..\..\app\rdw_csem;..\..\..\ip\ahi\api;..\..\..\driver\cobra_button;..\..\..\app\cobra_driver_test;..\..\..\driver\rdw_uart_driver;..\..\..\app\rdw_use_profile;..\..\..\ip\ble\profiles\hrp\hrps\api;..\..\..\ip\ble\profiles\hrp\hrps\src;..\..\..\ip\ble\profiles\hrp;..\..\..\ip\ble\profiles\blp\blps;..\..\..\ip\ble\profiles\blp\blps\src;..\..\..\ip\ble\profiles\blp\blps\api;..\..\..\app\app_button;..\..\..\app\rdw_console;..\..\..\app\src;..\..\..\app\new_uart_profile;..\..\..\ip\ble\mesh\api;..\..\..\ip\ble\mesh\inc;..\..\..\ip\ble\mesh\inc_al;..\..\..\ip\ble\mesh\src\inc;..\..\..\ip\ble\mesh\src\prf\inc;..\..\..\ip\ble\mesh\src\common\inc;..\..\..\ip\ble\mesh\src\models\inc;..\..\..\ip\ble\mesh\src\models\src;..\..\..\ip\ble\mesh\al;..\..\..\ip\ble\mesh\src\prf;..\..\..\ip\ble\mesh\src\models\src\gen\genc;..\..\..\ip\ble\mesh\src\models\src\gen\gens;..\..\..\app\app_mesh;..\..\..\driver\cobra_multi_timer;..\..\..\app\app_realtek\device1_collector;..\..\..\app\app_realtek\device1_uart;..\..\..\app\app_realtek\device2_uart;..\..\..\app\app_realtek\host_uart;..\..\..\app\app_realtek;..\..\..\app\app_realtek\realtek_calculate;..\..\..\app\app_realtek\realtek_device;..\..\..\app\app_realtek\uart_cmd_handler;..\..\..\driver\cobra_mmu;..\..\..\driver\cobra_softtimer;..\..\..\app\app_ota_master;..\..\..\app\app_shell;..\..\..\driver\rdw_queue;..\..\..\driver\cobra_src;..\..\..\driver\cobra_pll;..\..\..\app\app_mesh\app_leishunke;..\..\..\app\app_wireless_hid;..\..\..\app\app_example_ledbutton\inc;..\..\..\app\app_wireless_receiver;..\..\..\app\app_wireless_send;..\..\..\driver\app_adc;..\..\..\driver\cobra_wm8978;..\..\..\driver\rdw_prf_utils;..\..\..\app\app_meter_at_module;..\..\..\app\app_meter_at_module\slave_com_profile;..\..\..\app\app_meter_at_module\master_com_profile;..\..\..\app\app_meter_at_module\app_host1;..\..\..\app\app_meter_at_module\app_host2;..\..\..\app\sfud;..\..\..\app\app_at_command;..\..\..\app\app_easylogger;..\..\..\app\app_umouse;..\..\..\app\app_easylogger\inc;..\..\..\app\app_wireless_mcu;..\..\..\app\app_iris;..\..\..\app\app_iris\device1_collector;..\..\..\app\app_iris\device1_uart;..\..\..\app\app_iris\device2_collector;..\..\..\app\app_iris\device2_collector_delete;..\..\..\app\app_iris\device2_uart;..\..\..\app\app_iris\device3_collector;..\..\..\app\app_iris\device3_collector_delete;..\..\..\app\app_iris\host_uart;..\..\..\app\app_iris\iris_calculate;..\..\..\app\app_iris\iris_device;..\..\..\app\app_mesh\app_tulip;..\..\..\app\app_realtek\realtek_calculate;..\..\..\app\app_mesh\app_tuya;..\..\..\app\sfud\inc;..\..\..\app\app_mouse;..\build;..\..\..\app\app_airsync\service;..\..\..\app\app_airsync\service_task;..\..\..\app\app_airsync;..\source;..\app_mosquito_killing;..\..\..\lib
  asm define: SDK_BIN_ENABLE
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\mosquito_killing.sct
  link misc: ..\..\..\lib\cobra4_lib.txt --symdefs=.\app_ble.txt
  group main
    ../../../app/: main.c cobra4_common.c cobra4_ble_common.c cobra4_rdw_common.c
    ../../../plf/arch/: retargetio.c
    ../../../app/src/: sdk_project_bin.s
  group app
    ../../../app/src/: app.c app_task.c app_sec.c app_sec2.c app_batt.c app_blood.c app_dis.c app_heart_rate.c app_ht.c
    ../../../app/app_button/: app_button.c
  group cobra_driver
    ../../../driver/: cobra_system.c cobra4_aon_top.c cobra4_aon_wk.c cobra4_d_vad.c cobra_uart.c cobra_trng.c cobra_pcrm.c cobra_aon_dcdc.c cobra_pinmux.c cobra_soft_timer.c cobra_udma.c cobra_umcu.c cobra_dualtimer.c cobra_i2c.c cobra_i2s.c cobra_irda.c cobra_ceva_baseband.c cobra_cache_ctrl.c cobra_timer.c cobra_m4_gpio.c cobra4_systick.c cobra_spi_flash_ctrl.c cobra_sm4.c cobra_rtc.c cobra_ecc.c cobra_watchdog.c cobra_spi.c cobra4_aes.c cobra4_sm4.c cobra4_gpadc.c cobra4A_mpwm.c cobra4A_spwm.c cobra_util.c cobra4_audio.c cobra4_pll.c cobra_ecc_new.c cobra_sha256.c wm8978.c cobra4C_eflash_ctrl.c cobra_sleep.c cobra4_power_down.c cobra_soft_uart.c cobra_dualtimer_aon.c
    ../../../driver/app_rdw_gpio/: rdw_gpio.c
    ../../../driver/app_background_task/: app_bk_task.c
    ../../../driver/cobra_button/: cobra_button.c
    ../../../driver/cobra_multi_timer/: cobra_multi_timer.c
    ../../../driver/cobra_mmu/: cobra_mmu.c
    ../../../driver/cobra_softtimer/: cobra4A_link.c cobra4A_linked_softtimer.c
    ../../../driver/rdw_queue/: rdw_queue.c
    ../../../driver/cobra_src/: cobra_src.c
    ../../../driver/app_rdw_dma/: rdw_dma.c
    ../../../driver/cobra_wm8978/: cobra_wm8978.c
    ../../../driver/low_power_driver/: cobra_lowpower.c
    ../../../driver/app_adc/: rdw_adc.c
  group at_command
    ../../../app/app_at_command/: app_at_cmd.c cobra_cat.c
  group APP_CMD
    ../../../app/rdw_console/: rdw_command.c rdw_console.c
  group APP_MOSQUITO_KILLING
    ../app_mosquito_killing/: app_mosquito_killing.c mosquito_killing_data.c mosquito_killing_disp.c mosquito_killing_statistics.c mosquito_killing_protocol.c
  group APP_IRIS
    ../../../app/app_iris/: device1_scan.c device1_scan_task.c device1_connection.c device1_connection_task.c device2_connection.c device2_connection_task.c device3_connection.c device3_connection_task.c host_advertiser_task1.c host_advertiser1.c app_iris_console.c app_report_adv.c
    ../../../app/app_iris/host_uart/: app_host_uart.c
    ../../../app/app_iris/device2_uart/: app_host2_uart.c
    ../../../app/app_iris/iris_device/: app_iris_device.c
    ../../../app/app_iris/iris_calculate/: app_iris_calculate.c app_calculate_meter.c
  group APP_RT_PROTOCOL
    ../../../app/app_realtek/: app_autoconnect.c app_realtek_console.c app_report_adv.c device1_connection.c device1_connection_task.c device1_scan.c device1_scan_task.c device2_connection.c device2_connection_task.c device3_connection.c device3_connection_task.c host_advertiser_task1.c host_advertiser1.c app_realtek_rece_list.c
    ../../../app/app_realtek/device1_collector/: device1_client_uart.c device1_client_uart_task.c
    ../../../app/app_realtek/device1_uart/: device1_uart.c device1_uart_task.c
    ../../../app/app_realtek/host_uart/: app_host_uart.c
    ../../../app/app_realtek/realtek_calculate/: app_calculate_box.c app_calculate_meter.c app_realtek_calculate.c
    ../../../app/app_realtek/realtek_device/: app_realtek_device.c
    ../../../app/app_realtek/uart_cmd_handler/: app_realtek_uart_cmd_handler.c
    ../../../app/app_realtek/device2_uart/: app_host2_uart.c
  group APP_METER_AT_CMD
    ../../../app/app_meter_at_module/: master_scan.c master_scan_task.c module_report_adv.c slave_device1_connection.c slave_device1_connection_task.c app_master.c app_meter_common.c
    ../../../app/app_meter_at_module/slave_com_profile/: slave_com.c slave_com_task.c
    ../../../app/app_meter_at_module/master_com_profile/: master_com.c master_com_task.c
    ../../../app/app_meter_at_module/app_host1/: app_host1.c
  group APP_UART
    ../../../app/new_uart_profile/: app_new_uart.c new_uart.c uart_new_task.c app_uart_module.c
  group APP_OTA
    ../../../app/app_ota_master/: app_ota_scan.c app_ota_scan_task.c ota_device.c ota_device_task.c ota_master.c ota_master_task.c ota_shell.c ota_shell_cmd.c
  group APP_HID
    ../../../app/app_wireless_hid/: app_hid.c hid_key.c hogpd.c hogpd_task.c
  group APP_LED_BUTTON
    ../../../app/app_example_ledbutton/src/: app_led_button.c led_button.c led_button_task.c
  group APP_WIRELESS_SEND
    ../../../app/app_wireless_send/: adpcm_code.c app_i2s_record.c app_pdm_record.c app_rdw_voice.c app_voice_buffer.c rdw_voice.c rdw_voice_task.c voice_task.c
  group APP_WIRELESS_RECEIVE
    ../../../app/app_wireless_receiver/: app_voice.c cobra_ringbuffer.c sound_scan.c sound_scan_task.c voice_device.c voice_device_task.c voice_master.c voice_master_task.c voice_play_task.c
  group APP_SHELL
    ../../../app/app_shell/: app_rdw_shell.c shell.c shell_cmd_list.c shell_ext.c
  group APP_LOG
    ../../../app/app_easylogger/: app_easylogger.c
    ../../../app/app_easylogger/src/: elog.c elog_utils.c
    ../../../app/app_easylogger/port/: elog_port.c
  group APP_MCU
    ../../../app/app_wireless_mcu/: app_wireless_mcu.c app_wireless_test.c
  group APP_MOUSE
    ../../../app/app_mouse/: app_mouse.c
  group APP_SFUD
    ../../../app/sfud/: app_sfud.c
    ../../../app/sfud/src/: sfud.c sfud_sfdp.c
    ../../../app/sfud/port/: sfud_port.c
  group profile
    ../../../ip/ble/profiles/blp/blps/src/: blps.c blps_task.c
    ../../../ip/ble/profiles/hrp/hrps/src/: hrps.c hrps_task.c
  group ip
    ../../../ip/ble/ll/src/co/: ble_util_buf.c rwble.c
  group APP_WECHAT
    ../../../app/app_airsync/: app_ble_wechat.c
    ../../../app/app_airsync/service_task/: ble_wechat_task.c
    ../../../app/app_airsync/service/: ble_wechat_service.c
    ../source/: AES.c crc32.c md5.c mpbledemo2.c ble_wechat_util.c epb.c epb_MmBp.c app_wechat.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
